# Keil uVision project ambientLight.uvproj, settings and files
target Target 1 (166/167)
  device: XC2267-96F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE0FFFF) IROM(0xC00000-0xC0FFFF) IROM2(0xC10000-0xCBFFFF) CLOCK(20000000) MOD167 MODV2
  output: ambientLight +hex
  group app
    ../src/app/: ledCtrl.c ledCtrl.h main.c task.c task.h
  group srv
    ../src/srv/: led.c led.h type.h canSrv.c canSrv.h
  group drv
    ../src/drv/: ccu60.c ccu60.h clk.c clk.h pwm.c pwm.h SCS.C SCS.H START_V3.A66 XC22xxREGS.H io.c io.h can.c can.h
