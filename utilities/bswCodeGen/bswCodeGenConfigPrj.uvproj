# Keil uVision project bswCodeGenConfigPrj.uvproj, settings and files
target Target 1 (166/167)
  device: XC2267-96F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE0FFFF) IROM(0xC00000-0xC0FFFF) IROM2(0xC10000-0xCBFFFF) CLOCK(20000000) MOD167 MODV2
  output: bswCodeGenConfigPrj
  group Dave Files
    ./: Start_V3.A66 main.c SCS.C ccu60.c
